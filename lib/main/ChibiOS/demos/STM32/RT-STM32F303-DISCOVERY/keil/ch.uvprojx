# Keil uVision project ch.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: ch +hex
  c flags: Optim=3 oTime=1 wLevel=2
  c define: __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c misc: --c99 -USTM32F303xC
  c include: ..\;..\..\..\..\os\license;..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx;..\..\..\..\os\common\ext\CMSIS\include;..\..\..\..\os\common\ext\CMSIS\ST\STM32F3xx;..\..\..\..\os\common\ports\ARMCMx;..\..\..\..\os\common\ports\ARMCMx\compilers\RVCT;..\..\..\..\os\common\oslib\include;..\..\..\..\os\rt\include;..\..\..\..\os\hal\osal\rt;..\..\..\..\os\hal\include;..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY;..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\os\hal\ports\STM32\STM32F3xx;..\..\..\..\os\hal\ports\STM32\LLD\ADCv3;..\..\..\..\os\hal\ports\STM32\LLD\CANv1;..\..\..\..\os\hal\ports\STM32\LLD\DACv1;..\..\..\..\os\hal\ports\STM32\LLD\DMAv1;..\..\..\..\os\hal\ports\STM32\LLD\EXTIv1;..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2;..\..\..\..\os\hal\ports\STM32\LLD\I2Cv2;..\..\..\..\os\hal\ports\STM32\LLD\RTCv2;..\..\..\..\os\hal\ports\STM32\LLD\SPIv2;..\..\..\..\os\hal\ports\STM32\LLD\TIMv1;..\..\..\..\os\hal\ports\STM32\LLD\USARTv2;..\..\..\..\os\hal\ports\STM32\LLD\USBv1;..\..\..\..\os\hal\ports\STM32\LLD\xWDGv1;..\..\..\..\test\lib;..\..\..\..\test\rt\source\test
  asm misc: --cpreproc
  asm include: ..\;..\..\..\..\os\license;..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx;..\..\..\..\os\common\ports\ARMCMx
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT6: RAM 0x10000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x2000a000 size 0x1
  group startup
    ../../../../os/common/startup/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
    ../../../../os/common/startup/ARMCMx/devices/STM32F3xx/: cmparams.h
  group cmsis
    ../../../../os/common/ext/CMSIS/include/: core_cm4.h core_cmFunc.h
    ../../../../os/common/ext/CMSIS/ST/STM32F3xx/: stm32f3xx.h
  group kernel port
    ../../../../os/common/ports/ARMCMx/: chcore.c chcore.h chcore_timer.h chcore_v7m.h chcore_v7m.c mpu.h
    ../../../../os/common/ports/ARMCMx/compilers/RVCT/: chcoreasm_v7m.s chtypes.h
  group kernel
    ../../../../os/rt/include/: chalign.h ch.h chcond.h chdebug.h chdynamic.h chevents.h chmsg.h chmtx.h chregistry.h chschd.h chsem.h chstats.h chsys.h chthreads.h chtm.h chvt.h chchecks.h chcustomer.h chsystypes.h chtrace.h
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c chtrace.c
    ../../../../os/common/oslib/include/: chbsem.h chheap.h chmboxes.h chmemcore.h chmempools.h
    ../../../../os/common/oslib/src/: chheap.c chmboxes.c chmemcore.c chmempools.c
  group osal
    ../../../../os/hal/osal/rt/: osal.c osal.h
  group hal_port
    ../../../../os/hal/ports/STM32/STM32F3xx/: hal_ext_lld_isr.c hal_ext_lld_isr.h hal_lld.c hal_lld.h stm32_isr.h stm32_rcc.h stm32_registry.h
    ../../../../os/hal/ports/STM32/LLD/ADCv3/: hal_adc_lld.c hal_adc_lld.h
    ../../../../os/hal/ports/STM32/LLD/CANv1/: hal_can_lld.c hal_can_lld.h
    ../../../../os/hal/ports/STM32/LLD/DACv1/: hal_dac_lld.c hal_dac_lld.h
    ../../../../os/hal/ports/STM32/LLD/DMAv1/: stm32_dma.c stm32_dma.h
    ../../../../os/hal/ports/STM32/LLD/EXTIv1/: hal_ext_lld.c hal_ext_lld.h
    ../../../../os/hal/ports/STM32/LLD/RTCv2/: hal_rtc_lld.c hal_rtc_lld.h
    ../../../../os/hal/ports/STM32/LLD/I2Cv2/: hal_i2c_lld.c hal_i2c_lld.h
    ../../../../os/hal/ports/STM32/LLD/TIMv1/: hal_gpt_lld.c hal_gpt_lld.h hal_icu_lld.c hal_icu_lld.h hal_pwm_lld.c hal_pwm_lld.h hal_st_lld.c hal_st_lld.h stm32_tim.h
    ../../../../os/hal/ports/STM32/LLD/USARTv2/: hal_serial_lld.c hal_serial_lld.h hal_uart_lld.c hal_uart_lld.h
    ../../../../os/hal/ports/STM32/LLD/USBv1/: hal_usb_lld.c hal_usb_lld.h stm32_usb.h
    ../../../../os/hal/ports/STM32/LLD/xWDGv1/: hal_wdg_lld.c hal_wdg_lld.h
    ../../../../os/hal/ports/common/ARMCMx/: nvic.c
    ../../../../os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c hal_pal_lld.h
  group hal
    ../../../../os/hal/include/: hal.h hal_adc.h hal_buffers.h hal_can.h hal_channels.h hal_dac.h hal_ext.h hal_files.h hal_gpt.h hal_i2c.h hal_i2s.h hal_icu.h hal_ioblock.h hal_mac.h hal_mii.h hal_mmc_spi.h hal_mmcsd.h hal_pal.h hal_pwm.h hal_qspi.h hal_queues.h hal_rtc.h hal_sdc.h hal_serial.h hal_serial_usb.h hal_spi.h hal_st.h hal_streams.h hal_uart.h hal_usb.h hal_usb_cdc.h hal_wdg.h
    ../../../../os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_dac.c hal_ext.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_qspi.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_spi.c hal_st.c hal_uart.c hal_usb.c hal_wdg.c
  group board
    ../../../../os/hal/boards/ST_STM32F3_DISCOVERY/: board.c board.h
  group test
    ../../../../test/lib/: ch_test.c ch_test.h
    ../../../../test/rt/source/test/: test_root.c test_root.h test_sequence_001.c test_sequence_001.h test_sequence_002.c test_sequence_002.h test_sequence_003.c test_sequence_003.h test_sequence_004.c test_sequence_004.h test_sequence_005.c test_sequence_005.h test_sequence_006.c test_sequence_006.h test_sequence_007.c test_sequence_007.h test_sequence_008.c test_sequence_008.h test_sequence_009.c test_sequence_009.h test_sequence_010.c test_sequence_010.h test_sequence_011.c test_sequence_011.h test_sequence_012.c test_sequence_012.h test_sequence_013.c test_sequence_013.h
  group demo
    ../: main.c mcuconf.h chconf.h halconf.h
