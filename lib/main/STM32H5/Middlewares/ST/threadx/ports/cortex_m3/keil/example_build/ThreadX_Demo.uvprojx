# Keil uVision project ThreadX_Demo.uvprojx, settings and files
target ThreadX_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ThreadX_Demo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ../inc;../../../../common/inc
  asm misc: --cpreproc
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20000000 size 0x80000
  link misc: --first __tx_vectors --entry=__main
  group Source Group
    ./: tx_initialize_low_level.s sample_threadx.c
  group Library_Group
    ./: ThreadX_Library.lib
