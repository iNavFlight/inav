<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sample_threadx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tx.ewp</path>
  </project>
  <batchBuild/>
</workspace>


