# Keil uVision project ThreadX_Demo.uvprojx, settings and files
target ThreadX_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: sample_threadx
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\inc;..\..\..\..\common\inc
  asm misc: --cpreproc
  memory RVCT1: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x20000
  link misc: --first __tx_vectors --entry=__main
  group src
    ./: sample_threadx.c tx_initialize_low_level.s
  group lib
    ./Objects/: tx.lib
