<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sample_threadx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_threadx_module_manager.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_threadx_module.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\txm.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>tx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_threadx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>txm</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_threadx_module</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_threadx_module_manager</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
