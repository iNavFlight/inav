# IAR project sample_threadx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample_threadx.srec
  ILINK.IlinkOutputFile: sample_threadx.out
  ILINK.IlinkIcfFile: sample_threadx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_M.s sample_threadx.c tx_initialize_low_level.s
    Debug/Exe/: tx.a
