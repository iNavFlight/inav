# Keil uVision project sample_threadx_module.uvprojx, settings and files
target FVP Simulation Model (6140000::V6.14::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: sample_threadx_module
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\..\common_modules\inc, ..\..\..\..\..\common\inc, ..\..\..\..\..\ports_module\cortex_m33\ac6\inc, ..\demo_secure_zone
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  link misc: --entry demo_module_start --first __txm_module_preamble
  group Module Code
    ./: sample_threadx_module.c txm_module_preamble.S
    ../txm/Objects/: txm.lib
    ../demo_secure_zone/Objects/: demo_secure_zone_CMSE_Lib.o
software components: CMSIS:CORE 5.2.0
