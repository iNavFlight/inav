# Keil uVision project demo_threadx_non-secure_zone.uvprojx, settings and files
target FVP Simulation Model (6140000::V6.14::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: demo_threadx_non-secure_zone
  c flags: Optim=1 v6Lang=3 v6LangP=1 wLevel=2
  c misc: -Wno-unused-function -Wno-visibility -Wno-missing-noreturn -Wno-unused-parameter
  c include: ..\..\..\..\..\common\inc, ..\..\inc, ..\..\..\..\..\common_modules\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\RTE\Device\ARMCM33_DSP_FP_TZ\ARMCM33_AC6.sct
  group Non-secure Code
    ../: ThreadX_Library.lib
    ./: sample_threadx_module_manager.c
  group CMSE Library
    ../demo_secure_zone/: interface.h
    ../demo_secure_zone/Objects/: demo_secure_zone_CMSE_Lib.o
software components: CMSIS:CORE 5.2.0, Device:Startup 2.0.0
